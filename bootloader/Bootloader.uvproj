# Keil uVision project Bootloader.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: Bootloader +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Source Group 1
    ./src/: bootloader.c
    ./inc/: STC8H.h
