# Keil uVision project USB_HUB_Meter.uvproj, settings and files
target USB_HUB_Meter (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: USB_HUB_Meter +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  asm include: .\inc
  link misc: REMOVEUNUSED
  group src
    ./src/: main.c STC8G_H_Delay.c STC8G_H_GPIO.c STC8G_H_NVIC.c STC8G_H_UART.c STC8G_H_UART_Isr.c STC8G_H_Timer.c STC8G_H_Timer_Isr.c INA226.c procotol.c STC8G_H_I2C.c STC8G_H_I2C_Isr.c
  group inc
    ./inc/: config.h STC8G_H_Delay.h STC8G_H_GPIO.h STC8G_H_NVIC.h STC8G_H_UART.h STC8G_H_Timer.h STC8G_H_Switch.h STC8H.h Type_def.h INA226.h procotol.h STC8G_H_I2C.h
